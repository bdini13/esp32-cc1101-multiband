# Repository bdini13/esp32-cc1101-multiband (continued)

## KiCad design hardware/esp32-cc1101-multiband.kicad_pcb (continued)

Board: 4 copper layers, 121 parts (0 on the bottom side), 79 nets, no tracks yet.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_2.7mm_M2.5

File hardware/bom-draft.csv (part):

Reference,Value,Footprint,Proposed part,DNP,Qty per board,Qty for five,Status,Notes
B1,B0310J50100AHF,ESP32_CC1101_RF:TTM_B0310J50100AHF,B0310J50100AHF,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,
C1,22uF 25V,Capacitor_SMD:C_1206_3216Metric,CC1206MKX5R8BB226,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"22uF 25V X5R 1206; bias curve reviewed. Verify effective capacitance, aging and transient margin on hardware."
C2,22uF 25V,Capacitor_SMD:C_1206_3216Metric,CC1206MKX5R8BB226,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"22uF 25V X5R 1206; bias curve reviewed. Verify effective capacitance, aging and transient margin on hardware."
C3,4.7uF,Capacitor_SMD:C_0603_1608Metric,GRM188R61A475KE15D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C4,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C5,4.7nF 1kV,Capacitor_SMD:C_1206_3216Metric,CC1206KKX7RCBB472,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C6,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C7,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C8,DNP,Capacitor_SMD:C_0603_1608Metric,GRM188R61A475KE15D,yes,0,0,DNP_DEFAULT,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C9,4.7uF,Capacitor_SMD:C_0603_1608Metric,GRM188R61A475KE15D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C10,1uF,Capacitor_SMD:C_0603_1608Metric,CC0603KRX7R7BB105,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C11,10uF,Capacitor_SMD:C_0603_1608Metric,CC0603KRX5R6BB106,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C12,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C13,22uF 25V,Capacitor_SMD:C_1206_3216Metric,CC1206MKX5R8BB226,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"22uF 25V X5R 1206; bias curve reviewed. Verify effective capacitance, aging and transient margin on hardware."
C14,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C20,10uF,Capacitor_SMD:C_0603_1608Metric,CC0603KRX5R6BB106,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C21,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C22,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C23,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C24,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C25,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C26,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C30,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C31,15pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402JRNPO9BN150,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,15 pF C0G starting value uses TI typical 2.5 pF total stray: 15/2+2.5=10 pF. Measure/trim.
C32,15pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402JRNPO9BN150,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,15 pF C0G starting value uses TI typical 2.5 pF total stray: 15/2+2.5=10 pF. Measure/trim.
C40,100pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402JRNPO9BN101,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C41,100pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402JRNPO9BN101,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C42,0.6pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402BRNPO9BNR60,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C43,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C44,1.2pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402BRNPO9BN1R2,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C45,8pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402CRNPO9BN8R0,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C46,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C47,10pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402JRNPO9BN100,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C48,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C49,6.2pF C0G,Capacitor_SMD:C_0402_1005Metric,CC0402CRNPO9BN6R2,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C50,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C51,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C52,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C53,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C54,DNP,Capacitor_SMD:C_0402_1005Metric,,yes,0,0,DNP_DEFAULT,RF starting value; choose RF-rated series/Q/SRF and tune on actual PCB.
C60,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C61,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C70,10nF,Capacitor_SMD:C_0402_1005Metric,CC0402KRX7R9BB103,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
C71,100nF,Capacitor_SMD:C_0402_1005Metric,GRM155R71C104KA88D,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,"Verify selected tolerance, voltage/current rating and applicable DC-bias derating."
D1,USBLC6-2SC6,Package_TO_SOT_SMD:SOT-23-6,USBLC6-2SC6,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,
D2,PESD5V0S1UL,Diode_SMD:D_SOD-882,PESD5V0S1UL,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,
D3,STATUS GREEN,LED_SMD:LED_0603_1608Metric,APT1608LZGCK,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,
D4,POWER GREEN,LED_SMD:LED_0603_1608Metric,APT1608LZGCK,no,1,5,VERIFY_STOCK_AND_ASSEMBLY,
D5,RF ESD DNP,Diode_SMD:D_0402_1005Metric,,yes,0,0,DNP_DEFAULT,
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